# Repository Alex9779/Venta-LW-Controller

File README.md:

# Venta LW Controller
This project contains the electronics design, assembly and programming instructions for a board to be used in Venta airwashers of '[5 Series Classic](https://venta-usa.com/product-category/airwashers/5-series-classic/)' or '[LW Original](https://www.venta-luftwaescher.de/shop/alle-luftwaescher/original-bis-75-m2/)'  , see [Venta USA](https://venta-usa.com/) or [Venta Germany](https://www.venta-luftwaescher.de/).

The control board is based on an ESP32 module by [Espressif](https://www.espressif.com/) in particular an [ESP32-WROOM-32](http://espressif.com/zh-hans/products/hardware/esp-wroom-32/overview) module.

The intention of this project is to be able to control Venta airwashers remotely, in my case using [ESPHome](https://esphome.io/index.html) and [Home-Assistant](https://www.home-assistant.io/), that is turn it on and off and select the speed and also get information if it is on or off, what the current speed is and if it has an error.

But it is possible to use other tools to generate a firmware or write a completly own firmware for special needs.

## Board components
The board has six components:

1. ESP32 module
2. connector to the Venta airwasher
3. power supply circuit to transform 24V to 3.3V
4. button control circuit using BSS138 N-MOSFETs
5. LED state detection circut using diodes to block current to the ESP32's logic circuit
6. maintenance connector and buttons

## LED state detection circuit design and remarks
To detect the state of the LEDs and so the state of the airwasher diodes are used and the logic input of the ESP are set to HIGH in the PIN configuration of the firmware becuase of the design of the Venta control circuits.

The LEDs are under constant voltage and the control circuit closes when an LED shall be activated. Because of that we have constant 24V if and LED is off. Using a voltage divider to get that down to the ESP32's logic level is not possible because a voltage divider closes the circuit constantly even with very high resistor a little current flows throught the LEDs and as a result the LEDs shine a littel.

So the idea was to prevent current to the ESP32, set the PINs to HIGH and when the Venta controlle closes the circuit the PIN is pulled low.

In fact this works for the blue LEDs but not for the red one. So detecting error case is moved to the firmware logic. That relies on the fact that if the airwasher is on normally one of the speeds LEDs is lit, if not then the error LED is lit.

## Needed materials
| Amount | Part                                                                          | used model                         |
| :----: | ----------------------------------------------------------------------------- | ---------------------------------- |
|   1    | PCB                                                                           |
|   1    | ESP32-WROOOM-32 module                                                        |
|   1    | IDC plug for ribbon cable, 10 pins, 1.27mm cable pitch, 2.54mm contacts pitch | AMPHENOL T812110A101CEU            |
|   1    | IDC socket, 10 pins, 2.54mm contacts pitch                                    | AMPHENOL T821110A1S100CEU          |
|   1    | DC-DC buck converter, SO8, Uout 3.3V, Uin minimal 24V                         | Texas Instruments LM2674M-3.3/NOPB |
|   1    | tantalum capacitor, 22uF, 35VDC, Case D                                       | AVX TAJD226K035RNJ                 |
|   1    | tantalum capacitor, 100uF, 10VDC, Case C                                      | AVX TPSC107M010R0100               |
|   1    | Schottky diode, 30V                                                           | DIODES INCORPORATED B130-13-F      |
|   1    | wire inductor, 68uH, 12x12x6mm                                                | FERROCORE DE1205-68                |
|   1    | ceramic capacitor, 10nF, 0603                                                 |
|   1    | resistor, 10K, 0603                                                           |
|   2    | ceramic capacitor, 100nF, 0603                                                |
|   1    | ceramic capacitor, 10uF, 0603                                                 |
|   2    | resistor, 470R, 0603                                                          |
|   2    | resistor, 4K7, 0603                                                           |
|   2    | N-MOSFET, SOT-23                                                              | BSS138                             |
|   5    | diode, SOD-323                                                                | 1N4148WS                           |
|   1    | pin header, 4 pins, 2.54mm pitch                                              |
|   2    | TACT buttons, 6mm                                                             |

## Firmware
As described before I use ESPhome to generate a firmware and Home-Assistant to control the devices.

A sample ESPHome configuration to generate a firmware can be found in the 'ESPHome configuration sample' directoy of this repository. This sample also includes the configuration for an external Bluetooth temperature and humidity sensor [Xiaomi CGG1](https://esphome.io/components/sensor/xiaomi_cgg1.html).

## Installation
To installe the addtional PCB you have remove the fan module from your Venta airwasher and open it. With a flat screwdriver this is no real problem and it can be done without any damage, take you time and wiggle and bend the case also a little to get the points where it is clipped together, once you got the trick it is easy.

Here a Venta LW45:

Open the cover:

Remove the fan module:

Open the fan module:

Remove the seperator:

Remove the ribbon cable from the main board:

Add the addtional plug to the ribbon cable:

Put the PCB in the cover and connect the cable:

Add the seperator, connect the cable to the main board and close the fan module.

You're done!

## KiCad design Venta LW Controller.kicad_pcb

Parts:
C1: 22uF; CP_EIA-7343-31_Kemet-D
C2, C4: 100nF; C_0603_1608Metric
C3: 10uF; C_0603_1608Metric
C5: 10nF; C_0603_1608Metric
C6: 100uF; CP_EIA-6032-28_Kemet-C
D1: SK13; D_SMA
D2, D3, D4, D5, D6: 1N4148WS; D_SOD-323
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
L1: 68uH; L_12x12mm_H6mm
Q1, Q2: BSS138; SOT-23
R1: 10K; R_0603_1608Metric
R2, R3: 470R; R_0603_1608Metric
R4, R5: 4K7; R_0603_1608Metric
SW1: RST; SW_PUSH_6mm_H5mm
SW2: FLASH; SW_PUSH_6mm_H5mm
U1: LM2674N-3.3; SOIC-8_3.9x4.9mm_P1.27mm
U2: ESP32-WROOM-32

Connections:
+3.3V: C3.1, C4.1, C6.1, J1.2, L1.2, R1.1, U1.4 (FB), U2.2 (VDD)
+24V: C1.1, J2.1, U1.7 (VIN)
BTN_COVER: J2.5
BTN_FANSPEED: J2.9, Q2.3 (D)
BTN_POWER: J2.7, Q1.3 (D)
FLASH: SW2.1 (A), U2.25 (IO0)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, D1.2 (A), J1.1, J2.3, Q1.2 (S), Q2.2 (S), R4.1, R5.1, SW1.2 (B), SW2.2 (B), U1.6 (GND), U2.1 (GND), U2.15 (GND), U2.38 (GND), U2.39 (GND)
GPIO16: R3.2, U2.27 (IO16)
GPIO17: R2.2, U2.28 (IO17)
GPIO18: D6.2 (A), U2.30 (IO18)
GPIO19: D5.2 (A), U2.31 (IO19)
GPIO21: D4.2 (A), U2.33 (IO21)
GPIO22: D3.2 (A), U2.36 (IO22)
GPIO23: D2.2 (A), U2.37 (IO23)
LED_ERROR: D2.1 (K), J2.10
LED_HIGH: D3.1 (K), J2.8
LED_LOW: D5.1 (K), J2.4
LED_MID: D4.1 (K), J2.6
LED_POWER: D6.1 (K), J2.2
unnamed: C5.1, U1.1 (CB)
unnamed: C5.2, D1.1 (K), L1.1, U1.8 (VSW)
unnamed: Q1.1 (G), R2.1, R4.2
unnamed: Q2.1 (G), R3.1, R5.2
RST: C2.1, R1.2, SW1.1 (A), U2.3 (EN)
RXD: J1.3, U2.34 (RXD0/IO3)
TXD: J1.4, U2.35 (TXD0/IO1)

Board: 2 copper layers, 56.0 x 99.2 mm, 26 parts (10 on the bottom side), 25 nets.

## Code that names these connections

File ESPHome configuration sample/venta_output.h:

#include "esphome.h"
using namespace esphome;
 
const int PIN_SWITCH_FANSPEED = 16;
const int PIN_SWITCH_POWER = 17;
const int PIN_LED_POWER = 18;
const int PIN_LED_LOW = 19;
#if !defined(LW15)
const int PIN_LED_MID = 21;
#endif
const int PIN_LED_HIGH = 22;
 
#if !defined(LW15)
const float LOW_TO_MID = 0.33;
const float MID_TO_HIGH = 0.66;
#else
const float LOW_TO_MID = 0.5;
#endif
 
const int SWITCH_DELAY = 100;
const int SWITCH_INTERVAL = 200;
 
class VentaOutput : public Component, public FloatOutput {
  public:
    void setup() override {
      pinMode(PIN_SWITCH_FANSPEED, OUTPUT); // switch fanspeed
      pinMode(PIN_SWITCH_POWER, OUTPUT); // switch power
    }
 
    void write_state(float state) override {
      id(sensor_speed).publish_state(state);
 
      if (id(internal_error).state && state != -1) return;
 
      if (state >= 0 && state < LOW_TO_MID) { // switch off
        if (!digitalRead(PIN_LED_POWER)) {
          clickSwitch(PIN_SWITCH_POWER);
        }
      }
      else if (state >= LOW_TO_MID && state < MID_TO_HIGH) { // switch to low
        if (digitalRead(PIN_LED_POWER)) {
          clickSwitch(PIN_SWITCH_POWER);
        }
        while (digitalRead(PIN_LED_LOW)) // pin readings are inverted!
        {
          clickSwitch(PIN_SWITCH_FANSPEED);
          if (id(internal_error).state) {
            break;
          }
        }
      }
#if !defined(LW15)
      else if (state >= MID_TO_HIGH && state < 1) { //switch to mid
        if (digitalRead(PIN_LED_POWER)) {
          clickSwitch(PIN_SWITCH_POWER);
        }
        while (digitalRead(PIN_LED_MID)) // pin readings are inverted!
        {
          clickSwitch(PIN_SWITCH_FANSPEED);
          if (id(internal_error).state) {
            break;
          }
        }
      }
#endif
      else if (state == 1) {
        if (digitalRead(PIN_LED_POWER)) { // switch to high
          clickSwitch(PIN_SWITCH_POWER);
        }
        while (digitalRead(PIN_LED_HIGH)) // pin readings are inverted!
        {
          clickSwitch(PIN_SWITCH_FANSPEED);
          if (id(internal_error).state) {
            break;
          }
        }
      }
    }
 
  private:
    void clickSwitch(int pin) {
      digitalWrite(pin, true);
      delay(SWITCH_DELAY);
      digitalWrite(pin, false);
      delay(SWITCH_INTERVAL);
    }
};

## Commit log

2019-09-14 use usable GPIOs
2019-09-14 bumped version
2019-09-14 switched to ESP32
2019-09-17 updated tracks
2019-09-17 added keepout area
2019-09-17 corrected circuit and updated layout
2019-09-17 corrected circuit
2019-09-18 updated layout
2019-09-20 updated package
2019-09-26 updated values
2019-09-26 ignore bak files
2019-09-26 updated parts
2019-09-26 added and updated texts
2019-09-26 fixed transistor connection
2019-09-26 cleaned circuits
2019-09-26 rebuilt areas
2019-09-27 reworked
    - added correct circuit for BSS138
    - added voltage divider for inputs
    - changed buck converter setup
2019-10-07 changed voltage divider to diodes
2020-01-31 added cutout around antenna
2020-04-24 added README
2020-04-24 added ibom
2020-04-24 added ESPHome sample
2020-04-24 added images
2020-04-24 added cache lib
2020-04-24 refilled and rotated connector
2020-04-24 resized images
2020-04-24 renamed images
2020-04-24 added image
2020-04-24 added installation instructions
